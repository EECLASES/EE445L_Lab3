# Keil uVision project PeriodicSysTickInts.uvprojx, settings and files
target PeriodicSysTickInts (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x0,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PeriodicSysTickInts
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: RAM 0x0 size 0x40000
  memory RVCT9: ROM 0x20000000 size 0x8000
  group Source
    ./: startup.s PeriodicSysTickInts.c
    ../inc/: PLL.c SysTickInts.c
software components: CMSIS:CORE 5.1.2
